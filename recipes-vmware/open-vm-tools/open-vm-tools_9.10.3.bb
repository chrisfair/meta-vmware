include open-vm-tools.inc
SRCREV = "85693a5d68bbde94b76cafbbd5005d07c2a65723"
SRC_URI += "file://files_${PV}/vmtoolsd.service"

SRC_URI[md5sum] = "3777e30d72ed4098ecff16e6480cf1cc"
SRC_URI[sha256sum] = "380c0e83c61f3c8e1f101392f6b872c69e52f584dfe0bd15ba9984c1044497ae"

