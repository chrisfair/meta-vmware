COMPATIBLE_MACHINE_vmware = "(vmware|virtualbox)"
