COMPATIBLE_MACHINE = "(vmware|virtualbox)"
