RECOMMENDS_packagegroup-core-tools-profile:append_vmware = " systemtap"
